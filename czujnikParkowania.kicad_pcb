# Repository mariuszpozarlik/czujnikParkowania

## KiCad design czujnikParkowania.kicad_pcb

Parts:
BZ1: Buzzer; BUZZER
C1: 100u/25V; CP_Radial_D5.0mm_P2.00mm
C2, C3, C6, C7, C10, C11, C12, C13: 100n; C_0805_2012Metric
C4: 100u/6.3V; CP_Radial_D5.0mm_P2.50mm
C5: 10n; C_0805_2012Metric
C8, C9: 1p; C_0805_2012Metric
D1, D3, D4, D5, D6: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D2: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
F1: Fuse; R_Axial_DIN0207_L6.3mm_D2.5mm_P5.08mm_Vertical
J1: Screw_Terminal_01x03; TerminalBlock_Phoenix_MKDS-3-3-5.08_1x03_P5.08mm_Horizontal
Q1, Q3, Q4, Q5: BC817; SOT-23
Q2: IRF7404; SOIC-8_3.9x4.9mm_P1.27mm
R1, R4, R5, R6, R14: 1k; R_0805_2012Metric
R2: 10k; R_0805_2012Metric
R3: 3.3k; R_0805_2012Metric
R7, R8, R9, R10, R11, R12, R13: 330; R_0805_2012Metric
SW1: SW_Push; SW_SPST_B3S-1000
U1: DC56-11SEKWA; DA56-11SEKWA
U2: LM7805_TO220; TO-220-3_Vertical
U3: HC-SR04
U4: ATmega328-AU; TQFP-32_7x7mm_P0.8mm
Y1: Crystal; 16MHz cristal oscillator

Connections:
12V: F1.2, J1.1
+5V: BZ1.1 (-), C3.1, C4.1, C5.1, C6.1, C10.1, C11.1, C12.1, C13.1, D1.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), R4.1, U2.3 (VO), U3.1 (VCC), U4.4, U4.6, U4.18; also elsewhere on the board
/BTN: SW1.1, U4.31
/BUZZER: R5.2, U4.17
/ECHO: U3.3 (Echo), U4.13
/RGB_DI: D1.4 (DIN), U4.30
/SEG_1: R6.2, U4.15
/SEG_2: R14.2, U4.16
/SEG_A: R7.2, U4.32
/SEG_B: R8.2, U4.1
/SEG_C: R9.2, U4.2
/SEG_D: R10.2, U4.9
/SEG_E: R11.2, U4.10
/SEG_F: R12.2, U4.11
/SEG_G: R13.2, U4.12
/TRIG: U3.2 (Trig), U4.14
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, D1.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), J1.2, Q1.2 (E), Q3.2 (E), Q4.2 (E), Q5.2 (E), SW1.2, U2.2 (GND), U3.4 (GND), U4.3, U4.5, U4.21
unnamed: BZ1.2 (+), Q3.3 (C)
unnamed: C1.1, C2.1, Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), U2.1 (VI)
unnamed: C7.1, U4.20
unnamed: C8.2, U4.7, Y1.1
unnamed: C9.2, U4.8, Y1.2
unnamed: D1.2 (DOUT), D3.4 (DIN)
unnamed: D2.1 (K), Q2.1 (S), Q2.2 (S), Q2.3 (S), R1.1
unnamed: D2.2 (A), F1.1
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: Q1.1 (B), R3.1
unnamed: Q1.3 (C), R1.2, R2.2
unnamed: Q2.4 (G), R2.1
unnamed: Q3.1 (B), R5.1
unnamed: Q4.1 (B), R6.1
unnamed: Q4.3 (C), U1.14 (DIG1_CC)
unnamed: Q5.1 (B), R14.1
unnamed: Q5.3 (C), U1.13 (DIG2_CC)
unnamed 38: U4.29; also elsewhere on the board
unnamed: R7.1, U1.11 (DIG2_A), U1.16 (DIG1_A)
unnamed: R8.1, U1.10 (DIG2_B), U1.15 (DIG1_B)
unnamed: R9.1, U1.3 (DIG1_C), U1.8 (DIG2_C)
unnamed: R10.1, U1.2 (DIG1_D), U1.6 (DIG2_D)
unnamed: R11.1, U1.1 (DIG1_E), U1.5 (DIG2_E)
unnamed: R12.1, U1.12 (DIG2_F), U1.18 (DIG1_F)
unnamed: R13.1, U1.7 (DIG2_G), U1.17 (DIG1_G)
R: J1.3, R3.2

Board: 2 copper layers, 64.5 x 72.1 mm, 48 parts (0 on the bottom side), 45 nets.

Other parts of the board:
R4#2: 1k; R_0805_2012Metric

Their connections:
+5V: R4#2.1; also elsewhere on the board
unnamed 38: R4#2.2; also elsewhere on the board

## Commit log

2020-04-25 initial revision
2020-04-25 rev 2
2020-04-26 version with Amega only
2020-04-26 Only Atmega
2020-04-26 Adruino and Atmega328 on single board for code dev
2020-04-26 Added button
2020-04-26 bug on schematic and missing connection on PCB
2020-04-26 missing connections on PCB
2020-04-26 moved button
2020-04-26 added ground zones through vias
2020-04-26 bug fix
2020-04-27 added capacitors
2020-04-27 added caps and button
2020-04-29 added GND plane on back
2020-04-29 added GND plane on back. wrong brd in prev upload
2020-05-01 schematic reset pin bug fix
2020-05-01 schematic reset pin bugfix
